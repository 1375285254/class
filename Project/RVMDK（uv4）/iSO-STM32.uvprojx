# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\SYSTEM\usart2;..\..\HARDWARE\Computer;..\..\HARDWARE\deal_fg;..\..\HARDWARE\FPM10;..\..\HARDWARE\i2c;..\..\HARDWARE\key;..\..\HARDWARE\led;..\..\HARDWARE\PWM;..\..\HARDWARE\RTC;..\..\HARDWARE\Run;..\..\HARDWARE\finger
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../Libraries/CMSIS/: system_stm32f10x.c
  group HARDWARE
    ../../HARDWARE/Computer/: Computer.c
    ../../HARDWARE/deal_fg/: deal_fg.c
    ../../HARDWARE/FPM10/: FPM10A.c
    ../../HARDWARE/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../../HARDWARE/key/: key.c
    ../../HARDWARE/led/: led.c
    ../../HARDWARE/PWM/: pwm_config.c
    ../../HARDWARE/RTC/: bsp_calendar.c bsp_date.c bsp_rtc.c RTC_Time.c
    ../../HARDWARE/Run/: Run.c
    ../../HARDWARE/finger/: finger.c
  group FWLB
    ../../User/: stm32f10x_conf.h stm32f10x_it.h
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../../Libraries/CMSIS/: core_cm3.c
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
    ../../SYSTEM/usart2/: usart1.c usart5.c usart4.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.h
software components: CMSIS:CORE 4.3.0
